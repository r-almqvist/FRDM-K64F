# Keil uVision project FRDM-K64F.uvprojx, settings and files
target IoT Demo (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: MK64FN1M0VLL12 NXP
  pack: Keil.Kinetis_SDK_DFP.2.2.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x1FFF0000,0x10000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: FRDM-K64F
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: NDEBUG
  c include: $K\ARM\PACK\Keil\Kinetis_SDK_DFP\2.2.0\platform\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: .\RTE\Device\MK64FN1M0VLL12\MK64FN1M0xxx12_flash.scf
  group Application Code
    ./: main.c SensorThread.c HTTPServerCGI.c
    Web/: Web.c
  group Web
    ./Web/: jquery.min.js.gz smoothie.js.gz graph.html sensordata.cgx
software components: CMSIS:CORE 5.0.0, CMSIS:RTOS:Keil RTX 4.81.0, Board Support:Accelerometer 1.2, Board Support:LED 1.2, Board Support:Magnetometer 1.2, Network:CORE 7.2.0, Network:Interface:ETH 7.2.0, Network:Service:Web Server Compact 7.2.0, Network:Socket:TCP 7.2.0, Network:Socket:UDP 7.2.0, CMSIS Driver:Ethernet MAC 1.2, CMSIS Driver:Ethernet PHY:KSZ8081RNA 6.1, CMSIS Driver:I2C 1.3, Device:KSDK Configuration:FRDM-K64F 1.2.0, Device:KSDK Driver:GPIO 1.2.0, Device:KSDK Driver:RTC 1.2.0, Device:KSDK Driver:eDMA 1.2.0, Device:KSDK HAL:DMAMUX 1.2.0, Device:KSDK HAL:ENET 1.2.0, Device:KSDK HAL:GPIO 1.2.0, Device:KSDK HAL:I2C 1.2.0, Device:KSDK HAL:LPTMR 1.2.0, Device:KSDK HAL:MCG 1.2.0, Device:KSDK HAL:OSC 1.2.0, Device:KSDK HAL:PORT 1.2.0, Device:KSDK HAL:RTC 1.2.0, Device:KSDK HAL:SIM 1.2.0, Device:KSDK HAL:UART 1.2.0, Device:KSDK HAL:eDMA 1.2.0, Device:KSDK OSA:OSA 1.2.0, Device:KSDK System:Clock 1.2.0, Device:KSDK System:Interrupt 1.2.0, Device:KSDK Utility:Debug Console 1.2.0, Device:Startup 2.8
